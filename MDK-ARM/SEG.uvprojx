# Keil uVision project SEG.uvprojx, settings and files
target Template (6190000::V6.19::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SEG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER
  c include: ..\Drivers\CMSIS;..\Drivers\STM32G0xx_HAL_Driver\Inc;..\Drivers\System\sys;..\Drivers\System\delay;..\Drivers\System\usart;..\Drivers\Core\tim;..\Drivers\Core\iic;..\User;..\Drivers\BSP\LED;..\Drivers\BSP\SEG;..\Drivers\BSP\AT24CXX
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../Drivers/CMSIS/: startup_stm32g030xx.s
  group User
    ../User/: main.c stm32g0xx_it.c system_stm32g0xx.c stm32g0xx_hal_conf.h
  group Drivers/HAL
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c
  group Drivers/System
    ../Drivers/System/sys/: sys.c
    ../Drivers/System/delay/: delay.c
    ../Drivers/System/usart/: usart.c
  group Drivers/Core
    ../Drivers/Core/tim/: tim.c
    ../Drivers/Core/iic/: iic.c
  group Drivers/BSP
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/SEG/: seg.c
    ../Drivers/BSP/AT24CXX/: at24cxx.c
